# Keil uVision project shufa.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC8H1K08 Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x03FF) IROM(0-0x1FF8) CLOCK(35000000) MODP2
  output: shufa +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\shufa;.\192;.\ADC;.\key;.\POWER;.\TIME;.\PIR;.\CDS
  group shufa
    ./: shufa.c
    ./TIME/: tim.c
    ./key/: key.c
    ./ADC/: adc.c
    ./192/: lcd_192.c
    ./PIR/: pir.c
    ./CDS/: cds.c
